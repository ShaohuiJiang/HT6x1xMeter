<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Source</name>
    <group>
      <name>Libraries</name>
      <group>
        <name>CMSIS</name>
        <group>
          <name>CM0</name>
          <group>
            <name>CoreSupport</name>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\CMSIS\CM0\CoreSupport\core_cm0.c</name>
            </file>
          </group>
          <group>
            <name>DeviceSupport</name>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\CMSIS\CM0\DeviceSupport\ht6xxx.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\CMSIS\CM0\DeviceSupport\system_ht6xxx.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\CMSIS\CM0\DeviceSupport\system_ht6xxx.h</name>
            </file>
          </group>
        </group>
        <group>
          <name>HT60xx_StdPeriph_Driver</name>
          <group>
            <name>inc</name>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\inc\ht501x_emu.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\inc\ht501x_keyscan.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\inc\ht6xxx_aes&amp;rand.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\inc\ht6xxx_cmu.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\inc\ht6xxx_dma.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\inc\ht6xxx_exti.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\inc\ht6xxx_flash.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\inc\ht6xxx_gpio.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\inc\ht6xxx_iic.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\inc\ht6xxx_lcd.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\inc\ht6xxx_pmu.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\inc\ht6xxx_reset.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\inc\ht6xxx_rtc.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\inc\ht6xxx_spi.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\inc\ht6xxx_tbs.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\inc\ht6xxx_tdes&amp;rand.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\inc\ht6xxx_timer.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\inc\ht6xxx_uart&amp;7816.h</name>
            </file>
          </group>
          <group>
            <name>src</name>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\src\ht501x_emu.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\src\ht501x_keyscan.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_aes&amp;rand.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_cmu.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_dma.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_exti.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_flash.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_gpio.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_iic.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_lcd.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_pmu.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_reset.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_rtc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_spi.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_tbs.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_tdes&amp;rand.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_timer.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_uart&amp;7816.c</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\..\Source\Libraries\HT60xx_StdPeriph_Driver\ht6xxx_lib.h</name>
          </file>
        </group>
        <group>
          <name>Startup</name>
          <file>
            <name>$PROJ_DIR$\..\Source\Libraries\Startup\startup_ht6x1x.s</name>
          </file>
        </group>
      </group>
    </group>
    <group>
      <name>Tasks</name>
    </group>
    <group>
      <name>User</name>
      <file>
        <name>$PROJ_DIR$\..\Source\User\ht6xxx_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\User\ht6xxx_it.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\User\main.c</name>
      </file>
    </group>
  </group>
  <file>
    <name>$PROJ_DIR$\..\README.md</name>
  </file>
</project>


