# IAR project IAR_HT6x1xMeter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HT6X1X Hitrendtech HT6X1X
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: HT6x1x
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\Source\Libraries\HT60xx_StdPeriph_Driver; ..\Source\Libraries\HT60xx_StdPeriph_Driver\inc; ..\Source\Libraries\CMSIS\CM0\DeviceSupport; ..\Source\User
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAR_HT6x1xMeter.bin
  ILINK.IlinkOutputFile: IAR_HT6x1xMeter.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\flashloader\Hitrendtech\HT6X1X.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: README.md
  group Source/Libraries/CMSIS/CM0/CoreSupport
    ../Source/Libraries/CMSIS/CM0/CoreSupport/: core_cm0.c
  group Source/Libraries/CMSIS/CM0/DeviceSupport
    ../Source/Libraries/CMSIS/CM0/DeviceSupport/: ht6xxx.h system_ht6xxx.c system_ht6xxx.h
  group Source/Libraries/CMSIS/HT60xx_StdPeriph_Driver
    ../Source/Libraries/HT60xx_StdPeriph_Driver/: ht6xxx_lib.h
  group Source/Libraries/CMSIS/HT60xx_StdPeriph_Driver/inc
    ../Source/Libraries/HT60xx_StdPeriph_Driver/inc/: ht501x_emu.h ht501x_keyscan.h ht6xxx_aes&rand.h ht6xxx_cmu.h ht6xxx_dma.h ht6xxx_exti.h ht6xxx_flash.h ht6xxx_gpio.h ht6xxx_iic.h ht6xxx_lcd.h ht6xxx_pmu.h ht6xxx_reset.h ht6xxx_rtc.h ht6xxx_spi.h ht6xxx_tbs.h ht6xxx_tdes&rand.h ht6xxx_timer.h ht6xxx_uart&7816.h
  group Source/Libraries/CMSIS/HT60xx_StdPeriph_Driver/src
    ../Source/Libraries/HT60xx_StdPeriph_Driver/src/: ht501x_emu.c ht501x_keyscan.c ht6xxx_aes&rand.c ht6xxx_cmu.c ht6xxx_dma.c ht6xxx_exti.c ht6xxx_flash.c ht6xxx_gpio.c ht6xxx_iic.c ht6xxx_lcd.c ht6xxx_pmu.c ht6xxx_reset.c ht6xxx_rtc.c ht6xxx_spi.c ht6xxx_tbs.c ht6xxx_tdes&rand.c ht6xxx_timer.c ht6xxx_uart&7816.c
  group Source/Libraries/CMSIS/Startup
    ../Source/Libraries/Startup/: startup_ht6x1x.s
  group Source/User
    ../Source/User/: ht6xxx_it.c ht6xxx_it.h main.c
