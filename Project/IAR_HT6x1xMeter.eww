<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IAR_HT6x1xMeter.ewp</path>
  </project>
  <batchBuild/>
</workspace>


